FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI_append_apollo-distro = " file://devmem.cfg"
